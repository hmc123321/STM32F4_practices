# Keil uVision project ink_screen.uvprojx, settings and files
target ink_screen (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ink_screen +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;     ../Drivers/CMSIS/Include;     ..\User\Config;     ..\User\e-Paper;     ..\User\Fonts;     ..\User\GUI;     ..\User\Examples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group e-paper
    ../User/e-Paper/: EPD_1in02d.c EPD_1in54.c EPD_1in54_V2.c EPD_1in54b.c EPD_1in54b_V2.c EPD_1in54c.c EPD_1in64g.c EPD_2in7.c EPD_2in7b.c EPD_2in7b_V2.c EPD_2in9.c EPD_2in9_V2.c EPD_2in9b_V3.c EPD_2in9bc.c EPD_2in9d.c EPD_2in13.c EPD_2in13_V2.c EPD_2in13_V3.c EPD_2in13b_V3.c EPD_2in13b_V4.c EPD_2in13bc.c EPD_2in13d.c EPD_2in66.c EPD_2in66b.c EPD_3in0g.c EPD_3in7.c EPD_3in52.c EPD_4in01f.c EPD_4in2.c EPD_4in2b_V2.c EPD_4in2bc.c EPD_5in65f.c EPD_5in83.c EPD_5in83_V2.c EPD_5in83b_V2.c EPD_5in83bc.c EPD_7in3g.c EPD_7in5.c EPD_7in5_HD.c EPD_7in5_V2.c EPD_7in5b_HD.c EPD_7in5b_V2.c EPD_7in5bc.c
  group Config
    ../User/Config/: DEV_Config.c
  group GUI
    ../User/GUI/: GUI_Paint.c
  group Fonts
    ../User/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c
  group Examples
    ../User/Examples/: EPD_1in02_test.c EPD_1in54_test.c EPD_1in54_V2_test.c EPD_1in54b_test.c EPD_1in54b_V2_test.c EPD_1in54c_test.c EPD_1in64g_test.c EPD_2in7_test.c EPD_2in7b_test.c EPD_2in7b_V2_test.c EPD_2in9_test.c EPD_2in9_V2_test.c EPD_2in9b_V3_test.c EPD_2in9bc_test.c EPD_2in9d_test.c EPD_2in13_test.c EPD_2in13_V2_test.c EPD_2in13_V3_test.c EPD_2in13b_V3_test.c EPD_2in13b_V4_test.c EPD_2in13bc_test.c EPD_2in13d_test.c EPD_2in66_test.c EPD_2in66b_test.c EPD_3in0g_test.c EPD_3in7_test.c EPD_3in52_test.c EPD_4in01f_test.c EPD_4in2_test.c EPD_4in2b_V2_test.c EPD_4in2bc_test.c EPD_5in65f_test.c EPD_5in83_test.c EPD_5in83_V2_test.c EPD_5in83b_V2_test.c EPD_5in83bc_test.c EPD_7in3g_test.c EPD_7in5_HD_test.c EPD_7in5_test.c EPD_7in5_V2_test.c EPD_7in5b_HD_test.c EPD_7in5b_V2_test.c EPD_7in5bc_test.c ImageData.c ImageData2.c
software components: CMSIS:CORE 4.3.0
